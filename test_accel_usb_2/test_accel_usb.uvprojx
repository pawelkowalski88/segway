# Keil uVision project test_accel_usb.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_accel_usb
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,HSE_VALUE=8000000,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY
  c include: ..\test_accel_usb;C:\Keil_v5\ARM\Pack;.\Objects;..\stm32f429-master\stm32f429-master\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\stm32f429-master\stm32f429-master\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\stm32f429-master\stm32f429-master\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\stm32f429-master\stm32f429-master\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\stm32f429-master\stm32f429-master\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\stm32f429-master\stm32f429-master\00-STM32F429_LIBRARIES;..\stm32f429-master\stm32f429-master\00-STM32F429_LIBRARIES\usb_cdc_device
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: MadgwickAHRS.c quaternion.c tm_stm32f4_i2c.c tm_stm32f4_disco.c stm32f4xx_it.c main.c system_stm32f4xx.c PID.c
    ../stm32f429-master/stm32f429-master/00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_exti.c misc.c stm32f4xx_tim.c
    ../stm32f429-master/stm32f429-master/00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../stm32f429-master/stm32f429-master/00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../stm32f429-master/stm32f429-master/00-STM32F429_LIBRARIES/: tm_stm32f4_pwm.c tm_stm32f4_delay.c tm_stm32f4_timer_properties.c
